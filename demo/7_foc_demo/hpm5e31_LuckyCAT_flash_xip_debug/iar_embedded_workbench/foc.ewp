# IAR project foc.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: HPM5E31xPBx HPMicro HPM5E31xPBx
  General.GHeapSize: 0x4000
  ICCRISCV.IccLang: 2
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCExtraOptions: --diag_suppress Pa089; --diag_suppress Pe236; --diag_suppress Pe188; --diag_suppress Pe546; --diag_suppress Pe111
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_TFA=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_OWR=y; HPMSOC_HAS_HPMSDK_EUI=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_CRC=y; HPMSOC_HAS_HPMSDK_TSNS=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_EWDG=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMAV2=y; HPMSOC_HAS_HPMSDK_PPI=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_LOBS=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_MCAN=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_QEIV2=y; HPMSOC_HAS_HPMSDK_QEOV2=y; HPMSOC_HAS_HPMSDK_PWMV2=y; HPMSOC_HAS_HPMSDK_SDM=y; HPMSOC_HAS_HPMSDK_PLB=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_ENET=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_ESC=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_PLLCTLV2=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PDGO=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_HYBRID_XPI=y; HPMSOC_HAS_HPMSDK_PMP=y
  ICCRISCV.CCIncludePath2: ../../../../../../../sdk_env_v1.11.0/hpm_sdk/arch; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/arch/riscv/l1c; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/arch/riscv/intc; ../../../../../../boards/hpm5e31_LuckyCAT; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/soc/HPM5E00/HPM5E31; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/soc/HPM5E00/ip; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/soc/HPM5E00/HPM5E31/toolchains; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/soc/HPM5E00/HPM5E31/boot; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/drivers/inc; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/utils; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/components/debug_console; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/components/usb/device; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/middleware/cherryusb/common; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/middleware/cherryusb/osal; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/middleware/cherryusb/core; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/middleware/cherryusb/class/cdc; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/middleware/cherryusb/class/hid; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/middleware/cherryusb/class/midi; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/middleware/cherryusb/class/msc; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/middleware/cherryusb/class/audio; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/middleware/cherryusb/class/video; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/middleware/cherryusb/class/hub; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/middleware/cherryusb/class/wireless; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/middleware/cherryusb/port/ehci; ../../../../../../../sdk_env_v1.11.0/hpm_sdk/middleware/cherryusb/port/hpmicro; ../build_tmp/generated/include; ../../bsp/cherryusb/config
  IASMRISCV.AsmIncludePath: as above
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: demo.elf
  ILINK.IlinkConfigDefines: _flash_size=1M; _noncacheable_size=64K
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\sdk_env_v1.11.0\hpm_sdk\soc\HPM5E00\HPM5E31\toolchains\iar\flash_xip.icf
  ILINK.IlinkProgramEntryLabel: _start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_TFA=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_OWR=y; HPMSOC_HAS_HPMSDK_EUI=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_CRC=y; HPMSOC_HAS_HPMSDK_TSNS=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_EWDG=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMAV2=y; HPMSOC_HAS_HPMSDK_PPI=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_LOBS=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_MCAN=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_QEIV2=y; HPMSOC_HAS_HPMSDK_QEOV2=y; HPMSOC_HAS_HPMSDK_PWMV2=y; HPMSOC_HAS_HPMSDK_SDM=y; HPMSOC_HAS_HPMSDK_PLB=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_ENET=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_ESC=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_PLLCTLV2=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PDGO=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_HYBRID_XPI=y; HPMSOC_HAS_HPMSDK_PMP=y; NDEBUG
  group application/src
    D:/hpm_sdk_custom/samples/drivers/pwmv2/sync_output/src/: main.c
  group soc/HPM5E00/HPM5E31
    ../../../../../../../sdk_env_v1.11.0/hpm_sdk/soc/HPM5E00/HPM5E31/: system.c hpm_sysctl_drv.c hpm_clock_drv.c hpm_otp_drv.c hpm_pdgo_drv.c hpm_trgm_soc_drv.c hpm_qeiv2_soc_drv.c
  group soc/HPM5E00/HPM5E31/toolchains
    ../../../../../../../sdk_env_v1.11.0/hpm_sdk/soc/HPM5E00/HPM5E31/toolchains/: reset.c trap.c reset.c trap.c
  group soc/HPM5E00/HPM5E31/toolchains/iar
    ../../../../../../../sdk_env_v1.11.0/hpm_sdk/soc/HPM5E00/HPM5E31/toolchains/iar/: startup.s
  group soc/HPM5E00/HPM5E31/boot
    ../../../../../../../sdk_env_v1.11.0/hpm_sdk/soc/HPM5E00/HPM5E31/boot/: hpm_bootheader.c
  group arch/riscv/l1c
    ../../../../../../../sdk_env_v1.11.0/hpm_sdk/arch/riscv/l1c/: hpm_l1c_drv.c
  group boards/hpm5e31_LuckyCAT
    D:/hpm_sdk_custom/boards/hpm5e31_LuckyCAT/: pinmux.c board.c
  group drivers/src
    ../../../../../../../sdk_env_v1.11.0/hpm_sdk/drivers/src/: hpm_uart_drv.c hpm_i2c_drv.c hpm_pmp_drv.c hpm_gpio_drv.c hpm_spi_drv.c hpm_gptmr_drv.c hpm_pwmv2_drv.c hpm_pllctlv2_drv.c hpm_usb_drv.c hpm_acmp_drv.c hpm_enet_drv.c hpm_adc16_drv.c hpm_pcfg_drv.c hpm_ptpc_drv.c hpm_mchtmr_drv.c hpm_tsns_drv.c hpm_crc_drv.c hpm_sdm_drv.c hpm_mcan_drv.c hpm_qeiv2_drv.c hpm_enc_pos_drv.c hpm_qeov2_drv.c hpm_dmav2_drv.c hpm_ewdg_drv.c hpm_plb_drv.c hpm_tfa_drv.S hpm_esc_drv.c hpm_ppi_drv.c hpm_lobs_drv.c hpm_eui_drv.c hpm_owr_drv.c
  group utils
    ../../../../../../../sdk_env_v1.11.0/hpm_sdk/utils/: hpm_sbrk.c hpm_swap.c hpm_ffssi.c hpm_crc32.c
  group components/debug_console
    ../../../../../../../sdk_env_v1.11.0/hpm_sdk/components/debug_console/: hpm_debug_console.c
  group components/usb/device
    ../../../../../../../sdk_env_v1.11.0/hpm_sdk/components/usb/device/: hpm_usb_device.c
  group middleware/cherryusb/port/hpmicro
    ../../../../../../../sdk_env_v1.11.0/hpm_sdk/middleware/cherryusb/port/hpmicro/: usb_glue_hpm.c usb_dc_hpm.c
  group middleware/cherryusb/core
    ../../../../../../../sdk_env_v1.11.0/hpm_sdk/middleware/cherryusb/core/: usbotg_core.c usbd_core.c
  group middleware/cherryusb/class/cdc
    ../../../../../../../sdk_env_v1.11.0/hpm_sdk/middleware/cherryusb/class/cdc/: usbd_cdc_acm.c
